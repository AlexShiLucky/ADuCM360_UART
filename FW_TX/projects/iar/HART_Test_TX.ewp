# IAR project HART_Test_TX.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM360 AnalogDevices ADuCM360
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\inc\common; $TOOLKIT_DIR$\inc\AnalogDevices; $TOOLKIT_DIR$\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HART_Test_TX.hex
  ILINK.IlinkOutputFile: HART_Test_TX.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../inc/common/IAR/: startup_ADuCM360.s
  group common
    ../../inc/common/: ClkLib.c DioLib.c GptLib.c IntLib.c UrtLib.c WdtLib.c
  group src
    ../../src/: main.c
